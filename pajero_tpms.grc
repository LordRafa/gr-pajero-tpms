options:
  parameters:
    author: ttl
    description: Mirsubishi Pajero TPMS Decoder
    generate_options: qt_gui
    id: pajero_tpms
    output_language: python
    title: Pajero TPMS
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: freq_central
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: freq_sensor
  id: variable
  parameters:
    value: 432.9e6-15e3
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: 77e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: skip_seconds
  id: variable
  parameters:
    value: '600'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '7'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/decimation)/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: '4'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./records/tyres_rtl433_street.cf32
    offset: samp_rate*skip_seconds
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    log_level: err
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.1'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.1'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.8'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '0.3'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    GUI_Hint: '[0,0,1,2]'
    _source_code: "\"\"\"\nQT TPMS\n\"\"\"\n\nimport pmt\nimport struct\nimport time\n\nfrom gnuradio import gr\nfrom PyQt5.QtWidgets import QFrame, QVBoxLayout, QTableWidget, QTableWidgetItem\nfrom PyQt5.QtCore import QTimer, Qt\n\nclass Tpms_Widget(QFrame):\n    def __init__(self):\n        QFrame.__init__(self)\n\n        self.setFixedHeight(200)\n\n        self.tpms_info = {}\n\n        # Table widget\n        self.table = QTableWidget()\n        self.table.setColumnCount(6)\n        self.table.setHorizontalHeaderLabels([\"tid\", \"PSI\", \"Temp (Cº)\", \"RAD/s\", \"KM/h\" ,\"Seconds Since Update\"])\n        self.table.horizontalHeader().setStretchLastSection(True)\n\n        # Layout\n        layout = QVBoxLayout()\n        layout.addWidget(self.table)\n        self.setLayout(layout)\n\n        # Timer to update table every second\n        self.timer = QTimer()\n        self.timer.timeout.connect(self.update_table)\n        self.timer.start(1000)  # 1000 ms = 1s\n\n        # Initial population\n        self.update_table()\n        \n    def update_table(self):\n        # Resize table if number of entries changed\n        self.table.setRowCount(len(self.tpms_info))\n\n        # Fill table\n        now = time.time()\n        for row, (id_, values) in enumerate(self.tpms_info.items()):\n            seconds_since = int(now - values[\"timestamp\"])\n\n            self.table.setItem(row, 0, QTableWidgetItem(str(id_)))\n            self.table.setItem(row, 1, QTableWidgetItem(str(values['psi'])))\n            self.table.setItem(row, 2, QTableWidgetItem(str(values['temp'])))\n            self.table.setItem(row, 3, QTableWidgetItem(str(values['rad_s'])))\n            self.table.setItem(row, 4, QTableWidgetItem(str(values['km_h'])))\n            self.table.setItem(row, 5, QTableWidgetItem(str(seconds_since)))\n\n            # Align center\n            for col in range(6):\n                self.table.item(row, col).setTextAlignment(Qt.AlignCenter)\n\n    def add_tpms(self, sid, psi, temp, rad_s, km_h):\n        now = time.time()\n        self.tpms_info[sid] = {\"psi\": psi,  \"temp\": temp, \"rad_s\": rad_s, \"km_h\": km_h, \"timestamp\": now}\n\n\n\nclass Tpms_QT(gr.basic_block, Tpms_Widget):\n    \n    tpms_qt_init = False\n    \n    def __init__(self, GUI_Hint=[0, 0], tyre_diameter_mm = 1):\n        \"\"\"QT TPMS\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name=\"QT TPMS\",\n            in_sig=[],\n            out_sig=[],\n        )\n        \n        # Register message input\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n        self.GUI_Hint = GUI_Hint\n        self.tyre_diameter_mm = tyre_diameter_mm\n\n    def handle_msg(self, msg):\n        if pmt.is_dict(msg):\n            sid = pmt.dict_ref(msg, pmt.intern(\"sid\"), pmt.PMT_NIL)\n            psi = pmt.dict_ref(msg, pmt.intern(\"psi\"), pmt.PMT_NIL)\n            temp = pmt.dict_ref(msg, pmt.intern(\"temp\"), pmt.PMT_NIL)\n            rad_s = pmt.dict_ref(msg, pmt.intern(\"rad_s\"), pmt.PMT_NIL)\n            km_h = round(pmt.to_long(rad_s) * (self.tyre_diameter_mm / 2000) * 3.6)\n            self.add_tpms(sid, psi, temp, rad_s, km_h)\n\n    def initGUI(self, top_grid_layout):\n        if self.tpms_qt_init == False:\n            self.tpms_qt_init = True\n            Tpms_Widget.__init__(self)\n            GUI_Hint = self.GUI_Hint\n            match len(GUI_Hint):\n                case 2: top_grid_layout.addWidget(self, GUI_Hint[0], GUI_Hint[1])\n                case 4: top_grid_layout.addWidget(self, GUI_Hint[0], GUI_Hint[1], GUI_Hint[2], GUI_Hint[3])\n                case _: top_grid_layout.addWidget(self)\n\n"
    tyre_diameter_mm: '776'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Parser TPMS
      """

      import pmt
      import numpy as np
      import struct
      from gnuradio import gr

      class blk(gr.basic_block):
          """Parser TPMS"""
              
          def __init__(self):
              """Parser TPMS"""
              gr.basic_block.__init__(
                  self,
                  name="Parser TPMS",
                  in_sig=[np.uint8],    # input is stream of bytes
                  out_sig=[],           # no numeric stream output, we’ll use messages
              )
              self.message_port_register_out(pmt.intern("out"))
              self.message_port_register_out(pmt.intern("error"))
              # UU  IIIIIIII FR  PP TT BB  CC
              self.fmt =  "B4sBBBBB"
              self.size = struct.calcsize(self.fmt)
              self._buffer = bytearray()

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              self._buffer.extend(in0.tobytes())

              n = len(self._buffer) // self.size
              for i in range(n):
                  chunk = self._buffer[i*self.size:(i+1)*self.size]    
                  fields = struct.unpack(self.fmt, chunk)
                  msg = {
                      "bytes": chunk.hex(' '),
                      "state": hex(fields[0]),
                      "sid": fields[1].hex(),
                      "flags": (fields[2] & 0xF0) >> 4,
                      "repeat": fields[2] & 0x0F,
                      "psi": round(fields[3] * 1.364),
                      "temp": fields[4] - 50,
                      "rad_s": fields[5],
                      "crc": hex(fields[6]),
                  }
                  
                  if self.is_crc_valid(chunk[1:self.size -1], chunk[self.size - 1]):
                      self.message_port_pub(pmt.intern("out"), pmt.to_pmt(msg))
                  else:
                      self.message_port_pub(pmt.intern("error"), pmt.to_pmt(msg))
                  
              # keep leftover bytes
              self._buffer = self._buffer[n*self.size:]

              # tell scheduler we consumed everything from input
              self.consume(0, len(in0))
              return 0      

          def is_crc_valid(self, chunk, crc):
              calc_crc = 0
              for i in chunk:
                  calc_crc ^= i
              return calc_crc == crc
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nDecode TMPS:\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):\n    \"\"\"Decode TPMS\"\"\"\n\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name='Decode TPMS',   # will show up in GRC\n            in_sig=[np.uint8],\n            out_sig=[np.uint8]\n        )\n        #self.preamble = [1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1]\n        self.preamble = [1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,1,0,0,1]\n        #self.trailer = [1,0,0,0,0,0,1]\n        self.buffer = []\n        self.collecting = False\n\n    def manchester_decode(self, bits):\n        decoded = []\n        for i in range(0, len(bits) - 1, 2):\n            pair = (bits[i], bits[i+1])\n            if pair == (0, 1):\n                decoded.append(1)\n            elif pair == (1, 0):\n                decoded.append(0)\n            else:\n                raise ValueError(\"Error Manchester Decode\")\n        return decoded\n\n    def general_work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        n_out = 0\n        for bit in inp:\n            self.buffer.append(bit ^ 1)\n            \n            # If not collecting yet → check preamble\n            if not self.collecting:\n                if len(self.buffer) > len(self.preamble):\n                    self.buffer.pop(0)\n                    \n                if self.buffer == self.preamble:\n                    self.collecting = True\n                    self.buffer = []  # reset buffer after preamble\n                    continue\n\n            # If collecting → check trailer\n            if self.collecting and len(self.buffer) == 160:\n                # Output everything before the trailer\n                frame = self.buffer\n\n                try:\n                    # decode Manchester\n                    decoded = self.manchester_decode(frame)\n                    # copy to output buffer\n                    out[n_out:n_out+len(decoded)] = decoded\n                    n_out += len(decoded)\n                except ValueError as e:\n                    print(\"Droping invalid frame:\", e)\n                finally:\n                    # Reset for next frame\n                    self.buffer = []\n                    self.collecting = False\n\n        self.consume(0, len(inp))\n        return n_out\n        \n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (freq_sensor-freq_central)+(fsk_deviation/2)
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), transition_bw)'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color2: '"cyan"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Original
    label2: AGG
    name: FFT
    nconnections: '2'
    tr_level: '-25'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: Xlating
    name: FFT
    tr_level: '-1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    color3: black
    ctrlpanel: 'True'
    gui_hint: 3,0,1,2
    label1: Filter
    label2: Demod
    label3: Binary
    marker3: '0'
    name: Demod
    nconnections: '3'
    size: '1400'
    srate: samp_rate/decimation
    style1: '0'
    tr_delay: '0.00025'
    tr_level: '4'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '3'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color2: green
    color3: red
    ctrlpanel: 'True'
    gui_hint: 4,0,1,2
    label1: Binary
    label2: Sync
    label3: Error
    name: Sync
    nconnections: '3'
    size: '250'
    srate: samp_rate/decimation
    tr_delay: '0.0002'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    label1: Filter
    name: Filtered
    size: '1400'
    srate: samp_rate/decimation
    tr_delay: '0.00025'
    tr_level: '4'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '30'
    ymin: '-30'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      for _, field in vars(self).items():
      	if type(field).__name__ == "Tpms_QT":
      		field.initGUI(self.top_grid_layout)
    section: main_after_init
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq_central
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_quadrature_demod_cf_0, '0', blocks_threshold_ff_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_uchar_0, '0', epy_block_3, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_2, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0_0_0, '2']
- [epy_block_2, error, blocks_message_debug_0_0, log]
- [epy_block_2, out, blocks_message_debug_0, log]
- [epy_block_2, out, epy_block_0, in]
- [epy_block_3, '0', blocks_pack_k_bits_bb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_agc_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
